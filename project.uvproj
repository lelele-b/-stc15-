# Keil uVision project project.uvproj, settings and files
target Project (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\System;.\Hardware
  group User
    ./User/: main.c main.h
  group Hardware
    ./Hardware/: HC573.c HC573.h Hardware.h Seg.c Seg.h Timer.c Timer.h Key.c Key.h
  group System
    ./System/: Delay.c Delay.h IIC.c IIC.h UART.c UART.h EEPROM.c EEPROM.h ADC.c ADC.h RTC.c RTC.h TEMP.c TEMP.h
